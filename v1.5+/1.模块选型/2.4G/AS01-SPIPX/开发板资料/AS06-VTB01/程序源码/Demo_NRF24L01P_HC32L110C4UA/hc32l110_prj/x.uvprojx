# Keil uVision project x.uvprojx, settings and files
target x (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HC32L110C4UA HDSC
  pack: HDSC.HC32L110.1.0.3
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: 2401_rx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\app;.\driver\inc;.\mcu\common;.\drv\inc;.\periph\inc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group app
    ./app/: main.c
  group driver
    ./driver/src/: adc.c adt.c bt.c clk.c crc.c ddl.c flash.c gpio.c i2c.c interrupts_hc32l110.c lpm.c lpt.c lpuart.c lvd.c pca.c reset.c rtc.c spi.c trim.c uart.c vc.c wdt.c
  group common
    ./mcu/common/: startup_hc32l110.s system_hc32l110.c
  group drv
    ./drv/src/: drv_led.c drv_button.c drv_uart.c drv_spi.c drv_clk.c
  group periph
    ./periph/src/: drv_rf24l01.c
software components: CMSIS:CORE 5.4.0
